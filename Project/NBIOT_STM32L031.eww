<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\NBIOT_STM32L031.ewp</path>
    </project>
    <batchBuild />
</workspace>
